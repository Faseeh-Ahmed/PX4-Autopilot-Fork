## src/modules/custom_module/Kconfig
```kconfig
menuconfig MODULES_CUSTOM_MODULE
	bool "custom_module"
	default y
	---help---
		Enable custom module
```
