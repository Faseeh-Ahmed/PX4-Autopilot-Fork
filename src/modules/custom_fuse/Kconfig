## src/modules/custom_fuse/Kconfig
```kconfig
menuconfig MODULES_CUSTOM_FUSE
	bool "custom_fuse"
	default y
	---help---
		Enable support for custom_fuse
```
